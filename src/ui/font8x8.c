/**
 * @file font8x8.c
 * @brief 8x8 bitmap font
 */

#include "font8x8.h"

#include <stdbool.h>

#define FIRST_CHAR 32
#define LAST_CHAR 126
#define GLYPH_COUNT (LAST_CHAR - FIRST_CHAR + 1)

/* '#' is a lit pixel, '.' is unlit. Leftmost character is the leftmost pixel. */
static const char* const GLYPHS[GLYPH_COUNT][QDOS_FONT_H] = {
	/*   */ {"........","........","........","........","........","........","........","........"},
	/* ! */ {"..#.....","..#.....","..#.....","..#.....","..#.....","........","..#.....","........"},
	/* " */ {".#.#....",".#.#....","........","........","........","........","........","........"},
	/* # */ {".#.#....",".#.#....","#####...",".#.#....","#####...",".#.#....",".#.#....","........"},
	/* $ */ {"..#.....",".####...","#.#.....",".###....","..#.#...","####....","..#.....","........"},
	/* % */ {"##...#..","##..#...","...#....","..#.....",".#..##..","#...##..","........","........"},
	/* & */ {".##.....","#..#....","#.#.....",".#......","#.#.#...","#..#....",".##.#...","........"},
	/* ' */ {"..#.....","..#.....","........","........","........","........","........","........"},
	/* ( */ {"...#....","..#.....",".#......",".#......",".#......","..#.....","...#....","........"},
	/* ) */ {".#......","..#.....","...#....","...#....","...#....","..#.....",".#......","........"},
	/* * */ {"........","..#.....","#.#.#...",".###....","#.#.#...","..#.....","........","........"},
	/* + */ {"........","..#.....","..#.....","#####...","..#.....","..#.....","........","........"},
	/* , */ {"........","........","........","........","........","..#.....","..#.....",".#......"},
	/* - */ {"........","........","........","#####...","........","........","........","........"},
	/* . */ {"........","........","........","........","........","........","..#.....","........"},
	/* / */ {"....#...","....#...","...#....","..#.....",".#......","#.......","#.......","........"},
	/* 0 */ {".###....","#...#...","#..##...","#.#.#...","##..#...","#...#...",".###....","........"},
	/* 1 */ {"..#.....",".##.....","..#.....","..#.....","..#.....","..#.....",".###....","........"},
	/* 2 */ {".###....","#...#...","....#...","...#....","..#.....",".#......","#####...","........"},
	/* 3 */ {"####....","....#...","....#...",".###....","....#...","....#...","####....","........"},
	/* 4 */ {"...#....","..##....",".#.#....","#..#....","#####...","...#....","...#....","........"},
	/* 5 */ {"#####...","#.......","####....","....#...","....#...","#...#...",".###....","........"},
	/* 6 */ {"..##....",".#......","#.......","####....","#...#...","#...#...",".###....","........"},
	/* 7 */ {"#####...","....#...","...#....","..#.....",".#......",".#......",".#......","........"},
	/* 8 */ {".###....","#...#...","#...#...",".###....","#...#...","#...#...",".###....","........"},
	/* 9 */ {".###....","#...#...","#...#...",".####...","....#...","...#....",".##.....","........"},
	/* : */ {"........","........","..#.....","........","........","..#.....","........","........"},
	/* ; */ {"........","........","..#.....","........","........","..#.....","..#.....",".#......"},
	/* < */ {"...#....","..#.....",".#......","#.......",".#......","..#.....","...#....","........"},
	/* = */ {"........","........","#####...","........","#####...","........","........","........"},
	/* > */ {".#......","..#.....","...#....","....#...","...#....","..#.....",".#......","........"},
	/* ? */ {".###....","#...#...","....#...","...#....","..#.....","........","..#.....","........"},
	/* @ */ {".###....","#...#...","#.###...","#.#.#...","#.###...","#.......",".####...","........"},
	/* A */ {".###....","#...#...","#...#...","#####...","#...#...","#...#...","#...#...","........"},
	/* B */ {"####....","#...#...","#...#...","####....","#...#...","#...#...","####....","........"},
	/* C */ {".###....","#...#...","#.......","#.......","#.......","#...#...",".###....","........"},
	/* D */ {"###.....","#..#....","#...#...","#...#...","#...#...","#..#....","###.....","........"},
	/* E */ {"#####...","#.......","#.......","####....","#.......","#.......","#####...","........"},
	/* F */ {"#####...","#.......","#.......","####....","#.......","#.......","#.......","........"},
	/* G */ {".###....","#...#...","#.......","#.##....","#...#...","#...#...",".###....","........"},
	/* H */ {"#...#...","#...#...","#...#...","#####...","#...#...","#...#...","#...#...","........"},
	/* I */ {".###....","..#.....","..#.....","..#.....","..#.....","..#.....",".###....","........"},
	/* J */ {"....#...","....#...","....#...","....#...","#...#...","#...#...",".###....","........"},
	/* K */ {"#...#...","#..#....","#.#.....","##......","#.#.....","#..#....","#...#...","........"},
	/* L */ {"#.......","#.......","#.......","#.......","#.......","#.......","#####...","........"},
	/* M */ {"#...#...","##.##...","#.#.#...","#.#.#...","#...#...","#...#...","#...#...","........"},
	/* N */ {"#...#...","##..#...","#.#.#...","#.#.#...","#..##...","#...#...","#...#...","........"},
	/* O */ {".###....","#...#...","#...#...","#...#...","#...#...","#...#...",".###....","........"},
	/* P */ {"####....","#...#...","#...#...","####....","#.......","#.......","#.......","........"},
	/* Q */ {".###....","#...#...","#...#...","#...#...","#.#.#...","#..#....",".##.#...","........"},
	/* R */ {"####....","#...#...","#...#...","####....","#.#.....","#..#....","#...#...","........"},
	/* S */ {".####...","#.......","#.......",".###....","....#...","....#...","####....","........"},
	/* T */ {"#####...","..#.....","..#.....","..#.....","..#.....","..#.....","..#.....","........"},
	/* U */ {"#...#...","#...#...","#...#...","#...#...","#...#...","#...#...",".###....","........"},
	/* V */ {"#...#...","#...#...","#...#...","#...#...","#...#...",".#.#....","..#.....","........"},
	/* W */ {"#...#...","#...#...","#...#...","#.#.#...","#.#.#...","##.##...","#...#...","........"},
	/* X */ {"#...#...","#...#...",".#.#....","..#.....",".#.#....","#...#...","#...#...","........"},
	/* Y */ {"#...#...","#...#...",".#.#....","..#.....","..#.....","..#.....","..#.....","........"},
	/* Z */ {"#####...","....#...","...#....","..#.....",".#......","#.......","#####...","........"},
	/* [ */ {"..##....","..#.....","..#.....","..#.....","..#.....","..#.....","..##....","........"},
	/* \ */ {"#.......","#.......",".#......","..#.....","...#....","....#...","....#...","........"},
	/* ] */ {".##.....","..#.....","..#.....","..#.....","..#.....","..#.....",".##.....","........"},
	/* ^ */ {"..#.....",".#.#....","#...#...","........","........","........","........","........"},
	/* _ */ {"........","........","........","........","........","........","........","#####..."},
	/* ` */ {".#......","..#.....","........","........","........","........","........","........"},
	/* a */ {"........","........",".###....","....#...",".####...","#...#...",".####...","........"},
	/* b */ {"#.......","#.......","####....","#...#...","#...#...","#...#...","####....","........"},
	/* c */ {"........","........",".####...","#.......","#.......","#.......",".####...","........"},
	/* d */ {"....#...","....#...",".####...","#...#...","#...#...","#...#...",".####...","........"},
	/* e */ {"........","........",".###....","#...#...","#####...","#.......",".###....","........"},
	/* f */ {"..##....",".#..#...",".#......","####....",".#......",".#......",".#......","........"},
	/* g */ {"........","........",".####...","#...#...","#...#...",".####...","....#...",".###...."},
	/* h */ {"#.......","#.......","####....","#...#...","#...#...","#...#...","#...#...","........"},
	/* i */ {"..#.....","........",".##.....","..#.....","..#.....","..#.....",".###....","........"},
	/* j */ {"...#....","........","...#....","...#....","...#....","#..#....",".##.....","........"},
	/* k */ {"#.......","#.......","#..#....","#.#.....","##......","#.#.....","#..#....","........"},
	/* l */ {".##.....","..#.....","..#.....","..#.....","..#.....","..#.....",".###....","........"},
	/* m */ {"........","........","##.#....","#.#.#...","#.#.#...","#.#.#...","#.#.#...","........"},
	/* n */ {"........","........","####....","#...#...","#...#...","#...#...","#...#...","........"},
	/* o */ {"........","........",".###....","#...#...","#...#...","#...#...",".###....","........"},
	/* p */ {"........","........","####....","#...#...","#...#...","####....","#.......","#......."},
	/* q */ {"........","........",".####...","#...#...","#...#...",".####...","....#...","....#..."},
	/* r */ {"........","........","#.##....",".##.#...",".#......",".#......",".#......","........"},
	/* s */ {"........","........",".####...","#.......",".###....","....#...","####....","........"},
	/* t */ {".#......",".#......","####....",".#......",".#......",".#..#...","..##....","........"},
	/* u */ {"........","........","#...#...","#...#...","#...#...","#...#...",".####...","........"},
	/* v */ {"........","........","#...#...","#...#...","#...#...",".#.#....","..#.....","........"},
	/* w */ {"........","........","#...#...","#.#.#...","#.#.#...","#.#.#...",".#.#....","........"},
	/* x */ {"........","........","#...#...",".#.#....","..#.....",".#.#....","#...#...","........"},
	/* y */ {"........","........","#...#...","#...#...","#...#...",".####...","....#...",".###...."},
	/* z */ {"........","........","#####...","...#....","..#.....",".#......","#####...","........"},
	/* { */ {"...##...","..#.....","..#.....",".#......","..#.....","..#.....","...##...","........"},
	/* | */ {"..#.....","..#.....","..#.....","..#.....","..#.....","..#.....","..#.....","........"},
	/* } */ {".##.....","..#.....","..#.....","...#....","..#.....","..#.....",".##.....","........"},
	/* ~ */ {"........","........",".##..#..","#..##...","........","........","........","........"},
};

static uint8_t g_bitmap[GLYPH_COUNT][QDOS_FONT_H];
static bool g_packed = false;

static void pack(void) {
	for (int g = 0; g < GLYPH_COUNT; g++) {
		for (int row = 0; row < QDOS_FONT_H; row++) {
			uint8_t bits = 0;
			const char* art = GLYPHS[g][row];
			for (int col = 0; col < QDOS_FONT_W; col++)
				if (art[col] == '#')
					bits |= (uint8_t)(1u << col);
			g_bitmap[g][row] = bits;
		}
	}
	g_packed = true;
}

uint8_t qdos_font_row(char ch, int row) {
	if (row < 0 || row >= QDOS_FONT_H)
		return 0;

	unsigned char uc = (unsigned char)ch;
	if (uc < FIRST_CHAR || uc > LAST_CHAR)
		return 0;

	if (!g_packed)
		pack();

	return g_bitmap[uc - FIRST_CHAR][row];
}
